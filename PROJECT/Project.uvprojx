# Keil uVision project Project.uvprojx, settings and files
target Project (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\PROJECT;..\CORE;..\LIB\inc;..\USUALLY\adc;..\USUALLY\dac;..\USUALLY\delay;..\USUALLY\key;..\USUALLY\led;..\USUALLY\sys;..\USUALLY\timer;..\USUALLY\usart;..\USUALLY\nvic;..\USUALLY\FLASH
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ../CORE/: startup_stm32f10x_hd.s
  group Flib
    ../LIB/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c
  group core
    ../CORE/: core_cm3.c core_cm3.h
  group user
    ../CORE/: main.c stm32f10x_it.c system_stm32f10x.c
    ../USUALLY/adc/: bsp_adc.c
    ../USUALLY/dac/: bsp_dac.c
    ../USUALLY/delay/: delay.c
    ../USUALLY/key/: bsp_key.c
    ../USUALLY/led/: bsp_led.c
    ../USUALLY/sys/: sys.c
    ../USUALLY/timer/: bsp_timer.c
    ../USUALLY/usart/: bsp_usart1.c
    ../USUALLY/nvic/: nvic.c
    ../USUALLY/FLASH/: stmflash.c
